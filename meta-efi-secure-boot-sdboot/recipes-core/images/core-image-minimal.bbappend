require unified-kernel.inc